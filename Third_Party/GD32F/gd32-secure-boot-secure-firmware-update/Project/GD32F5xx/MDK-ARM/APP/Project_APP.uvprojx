# Keil uVision project Project_APP.uvprojx, settings and files
target Target_GDM32 (6240000::V6.24::ARMCLANG)
  device: GD32F527ZM GigaDevice
  pack: GigaDevice.GD32F5xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x100000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x400000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: app +hex
  AfterMake: python ..\..\..\afterbuild.py project_deal  -enc Flase -pn APP -op $L -on @L  -ide KEIL -ip $K
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PLATFORM_GD32F5XX
  c include: ..\..\..\..\Platform\GD32F5xx\Firmware\GD32F5xx_standard_peripheral\Include;..\..\..\..\Platform\GD32F5xx\Firmware\CMSIS\GD\GD32F5xx\Include;..\..\..\..\Platform\GD32F5xx;..\..\..\..\Platform\GD32F5xx\armclang;..\..\..\..\Platform\GD32F5xx\Utilities;..\..\..\..\Utilities\Third_Party\mcuboot-main\boot\bootutil\include;..\..\..\..\Utilities\Third_Party\mcuboot-main\boot\gigadevice;..\..\..\..\..\gd32-secure-boot-secure-firmware-update;..\..\..\..\Utilities\Third_Party\mcuboot-main\boot\gigadevice\include;..\..\..\..\Utilities\Third_Party\mbedtls-2.17.0\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x100000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\..\..\Platform\GD32F5xx\armclang\app_gdm32.sct
  link misc: --predefine="-DPLATFORM_GD32F5XX"   --entry=Reset_Handler --keep shellCommand*
  group application
    ../../../../Source/APP_Source/: main.c systick.c
    ../../../../Source/APP_Source/GD32F5xx/: gd32f5xx_it.c
  group CMSIS
    ../../../../Platform/GD32F5xx/Firmware/CMSIS/GD/GD32F5xx/Source/: system_gd32f5xx.c
  group Peripherals
    ../../../../Platform/GD32F5xx/Firmware/GD32F5xx_standard_peripheral/Source/: gd32f5xx_adc.c gd32f5xx_can.c gd32f5xx_cau.c gd32f5xx_cau_aes.c gd32f5xx_cau_des.c gd32f5xx_cau_tdes.c gd32f5xx_crc.c gd32f5xx_ctc.c gd32f5xx_dac.c gd32f5xx_dbg.c gd32f5xx_dci.c gd32f5xx_dma.c gd32f5xx_enet.c gd32f5xx_exmc.c gd32f5xx_exti.c gd32f5xx_fmc.c gd32f5xx_fwdgt.c gd32f5xx_gpio.c gd32f5xx_hau.c gd32f5xx_hau_sha_md5.c gd32f5xx_i2c.c gd32f5xx_i2c_add.c gd32f5xx_ipa.c gd32f5xx_iref.c gd32f5xx_misc.c gd32f5xx_pkcau.c gd32f5xx_pmu.c gd32f5xx_rcu.c gd32f5xx_rtc.c gd32f5xx_sai.c gd32f5xx_sdio.c gd32f5xx_spi.c gd32f5xx_syscfg.c gd32f5xx_timer.c gd32f5xx_tli.c gd32f5xx_trng.c gd32f5xx_usart.c gd32f5xx_wwdgt.c
  group Startup
    ../../../../Platform/GD32F5xx/Firmware/CMSIS/GD/GD32F5xx/Source/ARM/: startup_gd32f5xx.s
  group Utilities
    ../../../../Platform/GD32F5xx/Utilities/: gd32f527_eval.c
  group lib
    ../../../../Export/symbol/: mbl_symbol ibl_symbol_mbedtls
  group Letter_shell
    ../../../../Utilities/Third_Party/letter-shell-shell2.x/: shell.c shell_ext.c
    ../../../../Source/APP_Source/shell_drv_uart/: drv_uart.c
  group Common
    ../../../../Source/APP_Source/Common/: task.c reboot.c ymodem_update.c
  group Test
    ../../../../Source/Test_Source/APP_Test/: app_test_suit.c
software components: CMSIS:CORE 6.1.0
