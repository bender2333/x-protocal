# Keil uVision project Project_MBL.uvprojx, settings and files
target Target_GDM32 (6240000::V6.24::ARMCLANG)
  device: GD32F527ZM GigaDevice
  pack: GigaDevice.GD32F5xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x100000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x400000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: mbl +hex
  AfterMake: python ..\..\..\afterbuild.py project_deal -pn MBL -op $L -on @L  -ide KEIL -ip $K
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PLATFORM_GD32F5XX
  c include: ..\..\..\..\Platform\GD32F5xx\Firmware\GD32F5xx_standard_peripheral\Include;..\..\..\..\Platform\GD32F5xx\Firmware\CMSIS\GD\GD32F5xx\Include;..\..\..\..\Platform\GD32F5xx;..\..\..\..\Utilities\Third_Party\mbedtls-2.17.0\include;..\..\..\..\Platform\GD32F5xx\armclang;..\..\..\..\Platform\GD32F5xx\Firmware\CMSIS;..\..\..\..\Utilities\Third_Party\mcuboot-main\boot\gigadevice\include;..\..\..\..\Utilities\Third_Party\mcuboot-main\boot\bootutil\include;..\..\..\..\..\gd32-secure-boot-secure-firmware-update
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x100000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\..\..\Platform\GD32F5xx\armclang\mbl_gdm32.sct
  link misc: --predefine="-DPLATFORM_GD32F5XX"   --entry=Reset_Handler
  group bootloader
    ../../../../Source/MBL_Source/: mbl.c mbl_systick.c
    ../../../../Platform/GD32F5xx/: mbl_gd32f5xx_it.c
  group mcuboot_hal
    ../../../../Utilities/Third_Party/mcuboot-main/boot/gigadevice/flash_hal/: boot_hal.c flash_map.c keys.c
  group mcuboot
    ../../../../Utilities/Third_Party/mcuboot-main/boot/bootutil/src/: boot_record.c bootutil_misc.c bootutil_public.c caps.c encrypted.c fault_injection_hardening.c fault_injection_hardening_delay_rng_mbedtls.c image_ecdsa.c image_ed25519.c image_rsa.c image_validate.c loader.c swap_misc.c swap_move.c swap_scratch.c tlv.c
  group gdm32
    ../../../../Platform/GD32F5xx/armclang/: startup_gd32f5xx_mbl.s
    ../../../../Platform/GD32F5xx/Firmware/CMSIS/GD/GD32F5xx/Source/: system_gd32f5xx.c
    ../../../../Platform/GD32F5xx/Firmware/GD32F5xx_standard_peripheral/Source/: gd32f5xx_misc.c gd32f5xx_rcu.c gd32f5xx_usart.c gd32f5xx_gpio.c gd32f5xx_fmc.c gd32f5xx_syscfg.c
  group lib
    ../../../../Export/symbol/: ibl_symbol_mbedtls
