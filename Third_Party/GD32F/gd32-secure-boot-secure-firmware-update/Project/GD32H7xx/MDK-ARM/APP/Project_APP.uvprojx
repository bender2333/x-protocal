# Keil uVision project Project_APP.uvprojx, settings and files
target Target_GDM32 (6160000::V6.16::ARMCLANG)
  device: GD32H757VM GigaDevice
  pack: GigaDevice.GD32H7xx_DFP.1.2.0
  cpu: IRAM(0x24000000,0x000E0000) IRAM2(0x00000000,0x00010000) IROM(0x08000000,0x03C0000) XRAM(0x20000000,0x00010000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: app +hex
  AfterMake: python ..\..\..\afterbuild.py project_deal -pn APP -op $L -on @L  -ide KEIL -ip $K
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PLATFORM_GD32H7XX, APP_TEST_SUIT, USE_STDPERIPH_DRIVER, GD32H7XX
  c misc: -fshort-wchar
  c include: ..\..\..\..\Platform\GD32H7xx\Firmware\GD32H7xx_standard_peripheral\Include;..\..\..\..\Platform\GD32H7xx\Firmware\CMSIS\GD\GD32H7xx\Include;..\..\..\..\Platform\GD32H7xx;..\..\..\..\Platform\GD32H7xx\armclang;..\..\..\..\Platform\GD32H7xx\Utilities;..\..\..\..\Utilities\Third_Party\mcuboot-main\boot\bootutil\include;..\..\..\..\Utilities\Third_Party\mcuboot-main\boot\gigadevice;..\..\..\..\..\gd32-secure-boot-secure-firmware-update;..\..\..\..\Utilities\Third_Party\mcuboot-main\boot\gigadevice\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3c0000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: ..\..\..\..\Platform\GD32H7xx\armclang\app_gdm32.sct
  link misc: --predefine="-DPLATFORM_GD32H7XX"   --entry=Reset_Handler  --keep shellCommand*
  group application
    ../../../../Source/APP_Source/: main.c systick.c
    ../../../../Source/APP_Source/GD32H7xx/: gd32h7xx_it.c
  group CMSIS
    ../../../../Platform/GD32H7xx/Firmware/CMSIS/GD/GD32H7xx/Source/: system_gd32h7xx.c
  group Peripherals
    ../../../../Platform/GD32H7xx/Firmware/GD32H7xx_standard_peripheral/Source/: gd32h7xx_adc.c gd32h7xx_can.c gd32h7xx_cau.c gd32h7xx_cau_aes.c gd32h7xx_cau_des.c gd32h7xx_cau_tdes.c gd32h7xx_cmp.c gd32h7xx_cpdm.c gd32h7xx_crc.c gd32h7xx_ctc.c gd32h7xx_dac.c gd32h7xx_dbg.c gd32h7xx_dci.c gd32h7xx_dma.c gd32h7xx_edout.c gd32h7xx_efuse.c gd32h7xx_enet.c gd32h7xx_exmc.c gd32h7xx_exti.c gd32h7xx_fac.c gd32h7xx_fmc.c gd32h7xx_fwdgt.c gd32h7xx_gpio.c gd32h7xx_hau.c gd32h7xx_hau_sha_md5.c gd32h7xx_hpdf.c gd32h7xx_hwsem.c gd32h7xx_i2c.c gd32h7xx_ipa.c gd32h7xx_lpdts.c gd32h7xx_mdio.c gd32h7xx_mdma.c gd32h7xx_misc.c gd32h7xx_ospi.c gd32h7xx_ospim.c gd32h7xx_pmu.c gd32h7xx_rameccmu.c gd32h7xx_rcu.c gd32h7xx_rspdif.c gd32h7xx_rtc.c gd32h7xx_rtdec.c gd32h7xx_sai.c gd32h7xx_sdio.c gd32h7xx_spi.c gd32h7xx_syscfg.c gd32h7xx_timer.c gd32h7xx_tli.c gd32h7xx_tmu.c gd32h7xx_trigsel.c gd32h7xx_trng.c gd32h7xx_usart.c gd32h7xx_vref.c gd32h7xx_wwdgt.c
  group Startup
    ../../../../Platform/GD32H7xx/Firmware/CMSIS/GD/GD32H7xx/Source/ARM/: startup_gd32h7xx.s
  group Utilities
    ../../../../Platform/GD32H7xx/Utilities/: gd32h759i_eval.c
  group lib
    ../../../../Export/symbol/: mbl_symbol ibl_symbol_mbedtls
  group Letter_shell
    ../../../../Utilities/Third_Party/letter-shell-shell2.x/: shell.c shell_ext.c
    ../../../../Source/APP_Source/shell_drv_uart/: drv_uart.c
  group Common
    ../../../../Source/APP_Source/Common/: task.c reboot.c ymodem_update.c
  group Test
    ../../../../Source/Test_Source/APP_Test/: app_test_suit.c
software components: CMSIS:CORE 5.2.0
