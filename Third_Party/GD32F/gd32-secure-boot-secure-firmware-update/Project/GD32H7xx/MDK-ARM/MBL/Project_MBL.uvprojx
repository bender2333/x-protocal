# Keil uVision project Project_MBL.uvprojx, settings and files
target Target_GDM32 (6160000::V6.16::ARMCLANG)
  device: GD32H757VM GigaDevice
  pack: GigaDevice.GD32H7xx_DFP.1.2.0
  cpu: IRAM(0x24000000,0x000E0000) IRAM2(0x00000000,0x00010000) IROM(0x08000000,0x03C0000) XRAM(0x20000000,0x00010000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: mbl +hex
  AfterMake: python ..\..\..\afterbuild.py project_deal -pn MBL -op $L -on @L  -ide KEIL -ip $K
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PLATFORM_GD32H7XX, USE_STDPERIPH_DRIVER, GD32H7XX
  c misc: -fshort-wchar
  c include: ..\..\..\..\Platform\GD32H7xx\Firmware\GD32H7xx_standard_peripheral\Include;..\..\..\..\Platform\GD32H7xx\Firmware\CMSIS\GD\GD32H7xx\Include;..\..\..\..\Platform\GD32H7xx;..\..\..\..\Utilities\Third_Party\mbedtls-2.17.0\include;..\..\..\..\Platform\GD32H7xx\armclang;..\..\..\..\Platform\GD32H7xx\Firmware\CMSIS;..\..\..\..\Utilities\Third_Party\mcuboot-main\boot\gigadevice\include;..\..\..\..\Utilities\Third_Party\mcuboot-main\boot\bootutil\include;..\..\..\..\..\gd32-secure-boot-secure-firmware-update
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3c0000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: ..\..\..\..\Platform\GD32H7xx\armclang\mbl_gdm32.sct
  link misc: --predefine="-DPLATFORM_GD32H7XX"   --entry=Reset_Handler
  group bootloader
    ../../../../Source/MBL_Source/: mbl.c mbl_systick.c
    ../../../../Platform/GD32H7xx/: mbl_gd32h7xx_it.c
  group mcuboot_hal
    ../../../../Utilities/Third_Party/mcuboot-main/boot/gigadevice/flash_hal/: boot_hal.c flash_map.c keys.c
  group mcuboot
    ../../../../Utilities/Third_Party/mcuboot-main/boot/bootutil/src/: boot_record.c bootutil_misc.c bootutil_public.c caps.c encrypted.c fault_injection_hardening.c fault_injection_hardening_delay_rng_mbedtls.c image_ecdsa.c image_ed25519.c image_rsa.c image_validate.c loader.c swap_misc.c swap_move.c swap_scratch.c tlv.c
  group gdm32
    ../../../../Platform/GD32H7xx/armclang/: startup_gd32h7xx_mbl.s
    ../../../../Platform/GD32H7xx/Firmware/CMSIS/GD/GD32H7xx/Source/: system_gd32h7xx.c
    ../../../../Platform/GD32H7xx/Firmware/GD32H7xx_standard_peripheral/Source/: gd32h7xx_misc.c gd32h7xx_rcu.c gd32h7xx_usart.c gd32h7xx_gpio.c gd32h7xx_fmc.c
  group lib
    ../../../../Export/symbol/: ibl_symbol_mbedtls
