# Keil uVision project Project_APP.uvprojx, settings and files
target Target_GDM32 (6160000::V6.16::ARMCLANG)
  device: GD32F527IM GigaDevice
  pack: GigaDevice.GD32F5xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x110000) IROM(0x08000000,0x480000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: app +hex
  AfterMake: python ..\..\..\afterbuild.py project_deal  -enc Flase -pn APP -op $L -on @L  -ide KEIL -ip $K
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PLATFORM_GD32F5XX, APP_TEST_SUIT USE_IAP_TFTP USE_IAP_CAN
  c include: ..\..\..\..\Platform\GD32F5xx\Firmware\GD32F5xx_standard_peripheral\Include;..\..\..\..\Platform\GD32F5xx\Firmware\CMSIS\GD\GD32F5xx\Include;..\..\..\..\Platform\GD32F5xx;..\..\..\..\Platform\GD32F5xx\armclang;..\..\..\..\Platform\GD32F5xx\Utilities;..\..\..\..\Utilities\Third_Party\mcuboot-main\boot\bootutil\include;..\..\..\..\Utilities\Third_Party\mcuboot-main\boot\gigadevice;..\..\..\..\..\gd32-secure-boot-secure-firmware-update;..\..\..\..\Utilities\Third_Party\mcuboot-main\boot\gigadevice\include;..\..\..\..\Utilities\Third_Party\mbedtls-2.17.0\include;..\..\..\..\Utilities\Third_Party\lwip-2.1.2\src\include;..\..\..\..\Utilities\Third_Party\lwip-2.1.2\src\include\netif;..\..\..\..\Utilities\Third_Party\lwip-2.1.2\src\include\lwip;..\..\..\..\Utilities\Third_Party\lwip-2.1.2\port\GD32F5xx;..\..\..\..\Utilities\Third_Party\lwip-2.1.2\port\GD32F5xx\Basic;..\..\..\..\Source\APP_Source\GD32F5xx_tftp_can_iap\enet\inc;..\..\..\..\Source\APP_Source\Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x480000
  memory RVCT9: RAM 0x20000000 size 0x110000
  scatter file: ..\..\..\..\Platform\GD32F5xx\armclang\app_gdm32.sct
  link misc: --predefine="-DPLATFORM_GD32F5XX"   --entry=Reset_Handler --keep shellCommand*
  group application
    ../../../../Source/APP_Source/GD32F5xx_tftp_can_iap/: main.c gd32f5xx_it.c
    ../../../../Source/APP_Source/: systick.c
  group CMSIS
    ../../../../Platform/GD32F5xx/Firmware/CMSIS/GD/GD32F5xx/Source/: system_gd32f5xx.c
  group Peripherals
    ../../../../Platform/GD32F5xx/Firmware/GD32F5xx_standard_peripheral/Source/: gd32f5xx_adc.c gd32f5xx_can.c gd32f5xx_cau.c gd32f5xx_cau_aes.c gd32f5xx_cau_des.c gd32f5xx_cau_tdes.c gd32f5xx_crc.c gd32f5xx_ctc.c gd32f5xx_dac.c gd32f5xx_dbg.c gd32f5xx_dci.c gd32f5xx_dma.c gd32f5xx_enet.c gd32f5xx_exmc.c gd32f5xx_exti.c gd32f5xx_fmc.c gd32f5xx_fwdgt.c gd32f5xx_gpio.c gd32f5xx_hau.c gd32f5xx_hau_sha_md5.c gd32f5xx_i2c.c gd32f5xx_i2c_add.c gd32f5xx_ipa.c gd32f5xx_iref.c gd32f5xx_misc.c gd32f5xx_pkcau.c gd32f5xx_pmu.c gd32f5xx_rcu.c gd32f5xx_rtc.c gd32f5xx_sai.c gd32f5xx_sdio.c gd32f5xx_spi.c gd32f5xx_syscfg.c gd32f5xx_timer.c gd32f5xx_tli.c gd32f5xx_trng.c gd32f5xx_usart.c gd32f5xx_wwdgt.c
  group Startup
    ../../../../Platform/GD32F5xx/Firmware/CMSIS/GD/GD32F5xx/Source/ARM/: startup_gd32f5xx.s
  group Utilities
    ../../../../Platform/GD32F5xx/Utilities/: gd32f527_eval.c
  group lib
    ../../../../Export/symbol/: mbl_symbol ibl_symbol_mbedtls
  group Letter_shell
    ../../../../Utilities/Third_Party/letter-shell-shell2.x/: shell.c shell_ext.c
    ../../../../Source/APP_Source/shell_drv_uart/: drv_uart.c
  group Lwip
    ../../../../Utilities/Third_Party/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../Utilities/Third_Party/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../Utilities/Third_Party/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../Utilities/Third_Party/lwip-2.1.2/src/netif/: ethernet.c
  group Lwip_port
    ../../../../Utilities/Third_Party/lwip-2.1.2/port/GD32F5xx/Basic/: ethernetif.c
  group Enet
    ../../../../Source/APP_Source/GD32F5xx_tftp_can_iap/enet/src/: gd32f5xx_enet_eval.c netconf.c tftpserver.c enet_adapter.c
  group Common
    ../../../../Source/APP_Source/Common/: sys_init.c task.c reboot.c ymodem_update.c tftp_update.c can_update.c
  group Test
    ../../../../Source/Test_Source/APP_Test/: app_test_suit.c
software components: CMSIS:CORE 5.5.0
