# Keil uVision project Project_APP.uvprojx, settings and files
target Target_GDM32 (6160000::V6.16::ARMCLANG)
  device: GD32E507ZE GigaDevice
  pack: GigaDevice.GD32E50x_DFP.1.3.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: app +hex
  AfterMake: python ..\..\..\afterbuild.py project_deal -pn APP -plt PLATFORM_GD32E50X -op $L -on @L  -ide KEIL -ip $K
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PLATFORM_GD32E50X, APP_TEST_SUIT, USE_STDPERIPH_DRIVER, GD32E50X, GD32E50X_CL
  c misc: -fshort-wchar
  c include: ..\..\..\..\Platform\GD32E50x\Firmware\GD32E50x_standard_peripheral\Include;..\..\..\..\Platform\GD32E50x\Firmware\CMSIS\GD\GD32E50x\Include;..\..\..\..\Platform\GD32E50x;..\..\..\..\Platform\GD32E50x\armclang;..\..\..\..\Platform\GD32E50x\Utilities;..\..\..\..\Utilities\Third_Party\mcuboot-main\boot\bootutil\include;..\..\..\..\Utilities\Third_Party\mcuboot-main\boot\gigadevice;..\..\..\..\..\gd32-secure-boot-secure-firmware-update;..\..\..\..\Utilities\Third_Party\mcuboot-main\boot\gigadevice\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\Platform\GD32E50x\armclang\app_gdm32.sct
  link misc: --predefine="-DPLATFORM_GD32E50X"   --entry=Reset_Handler  --keep shellCommand*
  group application
    ../../../../Source/APP_Source/: main.c systick.c
    ../../../../Source/APP_Source/GD32E50x/: gd32e50x_it.c
  group CMSIS
    ../../../../Platform/GD32E50x/Firmware/CMSIS/GD/GD32E50x/Source/: system_gd32e50x.c
  group Peripherals
    ../../../../Platform/GD32E50x/Firmware/GD32E50x_standard_peripheral/Source/: gd32e50x_adc.c gd32e50x_bkp.c gd32e50x_can.c gd32e50x_cmp.c gd32e50x_crc.c gd32e50x_ctc.c gd32e50x_dac.c gd32e50x_dbg.c gd32e50x_dma.c gd32e50x_enet.c gd32e50x_exmc.c gd32e50x_exti.c gd32e50x_fmc.c gd32e50x_fwdgt.c gd32e50x_gpio.c gd32e50x_i2c.c gd32e50x_misc.c gd32e50x_pmu.c gd32e50x_rcu.c gd32e50x_rtc.c gd32e50x_sdio.c gd32e50x_shrtimer.c gd32e50x_spi.c gd32e50x_sqpi.c gd32e50x_timer.c gd32e50x_tmu.c gd32e50x_usart.c gd32e50x_wwdgt.c
  group Startup
    ../../../../Platform/GD32E50x/Firmware/CMSIS/GD/GD32E50x/Source/ARM/: startup_gd32e50x_cl.s
  group Utilities
    ../../../../Platform/GD32E50x/Utilities/: gd32e507z_eval.c
  group lib
    ../../../../Export/symbol/: mbl_symbol ibl_symbol_mbedtls
  group Letter_shell
    ../../../../Utilities/Third_Party/letter-shell-shell2.x/: shell.c shell_ext.c
    ../../../../Source/APP_Source/shell_drv_uart/: drv_uart.c
  group Common
    ../../../../Source/APP_Source/Common/: task.c reboot.c ymodem_update.c
  group Test
    ../../../../Source/Test_Source/APP_Test/: app_test_suit.c
software components: CMSIS:CORE 5.5.0
