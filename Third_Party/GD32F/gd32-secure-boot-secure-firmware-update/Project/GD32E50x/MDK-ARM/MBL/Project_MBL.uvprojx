# Keil uVision project Project_MBL.uvprojx, settings and files
target Target_GDM32 (6160000::V6.16::ARMCLANG)
  device: GD32E507ZE GigaDevice
  pack: GigaDevice.GD32E50x_DFP.1.3.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: mbl +hex
  AfterMake: python ..\..\..\afterbuild.py project_deal -pn MBL -plt PLATFORM_GD32E50X -op $L -on @L  -ide KEIL -ip $K
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PLATFORM_GD32E50X, USE_STDPERIPH_DRIVER, GD32A513, GD32E50X,GD32E50X_CL
  c misc: -fshort-wchar
  c include: ..\..\..\..\Platform\GD32E50x\Firmware\GD32E50x_standard_peripheral\Include;..\..\..\..\Platform\GD32E50x\Firmware\CMSIS\GD\GD32E50x\Include;..\..\..\..\Platform\GD32E50x;..\..\..\..\Utilities\Third_Party\mbedtls-2.17.0\include;..\..\..\..\Platform\GD32E50x\armclang;..\..\..\..\Platform\GD32E50x\Firmware\CMSIS;..\..\..\..\Utilities\Third_Party\mcuboot-main\boot\gigadevice\include;..\..\..\..\Utilities\Third_Party\mcuboot-main\boot\bootutil\include;..\..\..\..\..\gd32-secure-boot-secure-firmware-update
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\Platform\GD32E50x\armclang\mbl_gdm32.sct
  link misc: --predefine="-DPLATFORM_GD32E50X"   --entry=Reset_Handler
  group bootloader
    ../../../../Source/MBL_Source/: mbl.c mbl_systick.c
    ../../../../Platform/GD32E50x/: mbl_gd32e50x_it.c
  group mcuboot_hal
    ../../../../Utilities/Third_Party/mcuboot-main/boot/gigadevice/flash_hal/: boot_hal.c flash_map.c keys.c
  group mcuboot
    ../../../../Utilities/Third_Party/mcuboot-main/boot/bootutil/src/: boot_record.c bootutil_misc.c bootutil_public.c caps.c encrypted.c fault_injection_hardening.c fault_injection_hardening_delay_rng_mbedtls.c image_ecdsa.c image_ed25519.c image_rsa.c image_validate.c loader.c swap_misc.c swap_move.c swap_scratch.c tlv.c
  group gdm32
    ../../../../Platform/GD32E50x/armclang/: startup_gd32e50x_cl_mbl.s
    ../../../../Platform/GD32E50x/Firmware/CMSIS/GD/GD32E50x/Source/: system_gd32e50x.c
    ../../../../Platform/GD32E50x/Firmware/GD32E50x_standard_peripheral/Source/: gd32e50x_fmc.c gd32e50x_gpio.c gd32e50x_misc.c gd32e50x_rcu.c gd32e50x_usart.c
  group lib
    ../../../../Export/symbol/: ibl_symbol_mbedtls
