# Keil uVision project Project_APP.uvprojx, settings and files
target Target_GDM32 (6160000::V6.16::ARMCLANG)
  device: GD32A513VD GigaDevice
  pack: GigaDevice.GD32A513_DFP.1.0.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x060000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: app +hex
  AfterMake: python ..\..\..\afterbuild.py project_deal -pn APP -op $L -on @L  -ide KEIL -ip $K
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PLATFORM_GD32A513, APP_TEST_SUIT, USE_STDPERIPH_DRIVER, GD32A513
  c misc: -fshort-wchar
  c include: ..\..\..\..\Platform\GD32A513\Firmware\GD32A513_standard_peripheral\Include;..\..\..\..\Platform\GD32A513\Firmware\CMSIS\GD\GD32A513\Include;..\..\..\..\Platform\GD32A513;..\..\..\..\Platform\GD32A513\armclang;..\..\..\..\Platform\GD32A513\Utilities;..\..\..\..\Utilities\Third_Party\mcuboot-main\boot\bootutil\include;..\..\..\..\Utilities\Third_Party\mcuboot-main\boot\gigadevice;..\..\..\..\..\gd32-secure-boot-secure-firmware-update;..\..\..\..\Utilities\Third_Party\mcuboot-main\boot\gigadevice\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: ..\..\..\..\Platform\GD32A513\armclang\app_gdm32.sct
  link misc: --predefine="-DPLATFORM_GD32A513"   --entry=Reset_Handler  --keep shellCommand*
  group application
    ../../../../Source/APP_Source/: main.c systick.c
    ../../../../Source/APP_Source/GD32A513/: gd32a513_it.c
  group CMSIS
    ../../../../Platform/GD32A513/Firmware/CMSIS/GD/GD32A513/Source/: system_gd32a513.c
  group Peripherals
    ../../../../Platform/GD32A513/Firmware/GD32A513_standard_peripheral/Source/: gd32a513_adc.c gd32a513_bkp.c gd32a513_can.c gd32a513_cmp.c gd32a513_crc.c gd32a513_dac.c gd32a513_dbg.c gd32a513_dma.c gd32a513_exti.c gd32a513_fmc.c gd32a513_fwdgt.c gd32a513_gpio.c gd32a513_i2c.c gd32a513_mfcom.c gd32a513_misc.c gd32a513_pmu.c gd32a513_rcu.c gd32a513_rtc.c gd32a513_spi.c gd32a513_syscfg.c gd32a513_timer.c gd32a513_trigsel.c gd32a513_usart.c gd32a513_wwdgt.c
  group Startup
    ../../../../Platform/GD32A513/Firmware/CMSIS/GD/GD32A513/Source/ARM/: startup_gd32a513.s
  group Utilities
    ../../../../Platform/GD32A513/Utilities/: gd32a513v_eval.c
  group lib
    ../../../../Export/symbol/: mbl_symbol ibl_symbol_mbedtls
  group Letter_shell
    ../../../../Utilities/Third_Party/letter-shell-shell2.x/: shell.c shell_ext.c
    ../../../../Source/APP_Source/shell_drv_uart/: drv_uart.c
  group Common
    ../../../../Source/APP_Source/Common/: task.c reboot.c ymodem_update.c
  group Test
    ../../../../Source/Test_Source/APP_Test/: app_test_suit.c
software components: CMSIS:CORE 5.5.0
