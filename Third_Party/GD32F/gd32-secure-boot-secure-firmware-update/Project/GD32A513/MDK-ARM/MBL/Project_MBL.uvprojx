# Keil uVision project Project_MBL.uvprojx, settings and files
target Target_GDM32 (6160000::V6.16::ARMCLANG)
  device: GD32A513VD GigaDevice
  pack: GigaDevice.GD32A513_DFP.1.0.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x060000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: mbl +hex
  AfterMake: python ..\..\..\afterbuild.py project_deal -pn MBL -op $L -on @L  -ide KEIL -ip $K
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PLATFORM_GD32A513, USE_STDPERIPH_DRIVER, GD32A513
  c misc: -fshort-wchar
  c include: ..\..\..\..\Platform\GD32A513\Firmware\GD32A513_standard_peripheral\Include;..\..\..\..\Platform\GD32A513\Firmware\CMSIS\GD\GD32A513\Include;..\..\..\..\Platform\GD32A513;..\..\..\..\Utilities\Third_Party\mbedtls-2.17.0\include;..\..\..\..\Platform\GD32A513\armclang;..\..\..\..\Platform\GD32A513\Firmware\CMSIS;..\..\..\..\Utilities\Third_Party\mcuboot-main\boot\gigadevice\include;..\..\..\..\Utilities\Third_Party\mcuboot-main\boot\bootutil\include;..\..\..\..\..\gd32-secure-boot-secure-firmware-update
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: ..\..\..\..\Platform\GD32A513\armclang\mbl_gdm32.sct
  link misc: --predefine="-DPLATFORM_GD32A513"   --entry=Reset_Handler
  group bootloader
    ../../../../Source/MBL_Source/: mbl.c mbl_systick.c
    ../../../../Platform/GD32A513/: mbl_gd32a513_it.c
  group mcuboot_hal
    ../../../../Utilities/Third_Party/mcuboot-main/boot/gigadevice/flash_hal/: boot_hal.c flash_map.c keys.c
  group mcuboot
    ../../../../Utilities/Third_Party/mcuboot-main/boot/bootutil/src/: boot_record.c bootutil_misc.c bootutil_public.c caps.c encrypted.c fault_injection_hardening.c fault_injection_hardening_delay_rng_mbedtls.c image_ecdsa.c image_ed25519.c image_rsa.c image_validate.c loader.c swap_misc.c swap_move.c swap_scratch.c tlv.c
  group gdm32
    ../../../../Platform/GD32A513/armclang/: startup_gd32a513_mbl.s
    ../../../../Platform/GD32A513/Firmware/CMSIS/GD/GD32A513/Source/: system_gd32a513.c
    ../../../../Platform/GD32A513/Firmware/GD32A513_standard_peripheral/Source/: gd32a513_misc.c gd32a513_rcu.c gd32a513_usart.c gd32a513_gpio.c gd32a513_fmc.c gd32a513_syscfg.c
  group lib
    ../../../../Export/symbol/: ibl_symbol_mbedtls
