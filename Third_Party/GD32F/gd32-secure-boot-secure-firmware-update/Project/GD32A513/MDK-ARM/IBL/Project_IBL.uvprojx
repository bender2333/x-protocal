# Keil uVision project Project_IBL.uvprojx, settings and files
target Target_GDM32 (6160000::V6.16::ARMCLANG)
  device: GD32A513VD GigaDevice
  pack: GigaDevice.GD32A513_DFP.1.0.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x060000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: ibl +hex
  AfterMake: python ..\..\..\afterbuild.py project_deal -pn IBL -plt PLATFORM_GD32A513  -op $L -on @L  -ide KEIL -ip $K
  c flags: Optim=2 OneElfS=1 v6Lang=4 v6LangP=4 wLevel=1
  c define: IBL_PROJECT, USE_STDPERIPH_DRIVER, GD32A513,  PLATFORM_GD32A513 MBEDTLS_ROM_TEST
  c misc: -fshort-wchar
  c include: ..\..\..\..\Platform\GD32A513\Firmware\GD32A513_standard_peripheral\Include;..\..\..\..\Platform\GD32A513\Firmware\CMSIS\GD\GD32A513\Include;..\..\..\..\Platform\GD32A513\Firmware\CMSIS;..\..\..\..\Utilities\Third_Party\mbedtls-2.17.0\include;..\..\..\..\Platform\GD32A513;..\..\..\..\Source\Test_Source\IBL_Test;..\..\..\..\..\gd32-secure-boot-secure-firmware-update
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: ..\..\..\..\Platform\GD32A513\armclang\ibl_gdm32.sct
  link misc: --predefine="-DPLATFORM_GD32A513" --symdefs=.\rom_symbol_verify  --entry=Reset_Handler --keep=*
  group bootloader
    ../../../../Source/IBL_Source/: ibl_sys.c ibl_api.c ibl_heap.c ibl_state.c ibl_trace.c ibl.c ibl_key_derive.c ibl_image_validate.c ibl_hmac.c ibl_key.c ibl_stdlib.c ibl_boot.c
  group mbedtls
    ../../../../Utilities/Third_Party/mbedtls-2.17.0/library/: aes.c aes_alt.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c des_alt.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    ../../../../Source/IBL_Source/: ibl_ssl_self_test.c ibl_curve25519.c
  group halcomm
    ../../../../Platform/IBL/: ibl_cache.c ibl_efuse.c ibl_flash.c ibl_target_cfg.c ibl_trng.c ibl_uart.c ibl_security.c ibl_systick.c ymodem.c
    ../../../../Platform/GD32A513/: ibl_gd32a513_it.c
  group gdm32
    ../../../../Platform/GD32A513/armclang/: startup_gd32a513_ibl.s
    ../../../../Platform/GD32A513/Firmware/CMSIS/GD/GD32A513/Source/: ibl_system_gd32a513.c
    ../../../../Platform/GD32A513/Firmware/GD32A513_standard_peripheral/Source/: gd32a513_rcu.c gd32a513_pmu.c gd32a513_misc.c gd32a513_gpio.c gd32a513_fwdgt.c gd32a513_fmc.c gd32a513_usart.c gd32a513_syscfg.c
  group test
    ../../../../Source/Test_Source/IBL_Test/: ibl_test_suit.c
