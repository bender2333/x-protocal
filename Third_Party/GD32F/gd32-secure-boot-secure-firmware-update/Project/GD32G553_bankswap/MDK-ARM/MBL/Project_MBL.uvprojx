# Keil uVision project Project_MBL.uvprojx, settings and files
target Target_GDM32 (6120000::V6.12::.\ARMCLANG)
  device: GD32G553RE GigaDevice
  pack: GigaDevice.GD32G5x3_DFP.0.2.2
  cpu: IRAM(0x20000000,0x18000) IRAM2(0x10000000,0x8000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: mbl +hex
  AfterMake: python ..\..\..\afterbuild.py project_deal -pn MBL -op $L -on @L  -ide KEIL -ip $K
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PLATFORM_GD32G5X3, USE_STDPERIPH_DRIVER, GD32G5X3,GD32G5X3_BANKSWAP
  c misc: -fshort-wchar
  c include: ..\..\..\..\Utilities\Third_Party\mbedtls-2.17.0\include;..\..\..\..\Utilities\Third_Party\mcuboot-main\boot\gigadevice\include;..\..\..\..\Utilities\Third_Party\mcuboot-main\boot\bootutil\include;..\..\..\..\..\gd32-secure-boot-secure-firmware-update;..\..\..\..\Platform\GD32G5x3\Firmware\GD32G5x3_standard_peripheral\Include;..\..\..\..\Platform\GD32G5x3\Firmware\CMSIS\GD\GD32G5x3\Include;..\..\..\..\Platform\GD32G5x3;..\..\..\..\Platform\GD32G5x3\armclang;..\..\..\..\Platform\GD32G5x3\Firmware\CMSIS\GD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: ..\..\..\..\Platform\GD32G5x3\armclang\mbl_gdm32_bankswap.sct
  link misc: --predefine="-DPLATFORM_GD32G5X3 -DGD32G5X3_BANKSWAP"   --entry=Reset_Handler
  group bootloader
    ../../../../Source/MBL_Source/: mbl.c mbl_systick.c
    ../../../../Platform/GD32G5x3/: mbl_gd32g533_it.c
  group mcuboot_hal
    ../../../../Utilities/Third_Party/mcuboot-main/boot/gigadevice/flash_hal/: boot_hal.c flash_map.c keys.c
  group mcuboot
    ../../../../Utilities/Third_Party/mcuboot-main/boot/bootutil/src/: boot_record.c bootutil_misc.c bootutil_public.c caps.c encrypted.c fault_injection_hardening.c fault_injection_hardening_delay_rng_mbedtls.c image_ecdsa.c image_ed25519.c image_rsa.c image_validate.c loader.c swap_misc.c swap_move.c swap_scratch.c tlv.c
  group gdm32
    ../../../../Platform/GD32G5x3/armclang/: startup_gd32g533_mbl.s
    ../../../../Platform/GD32G5x3/Firmware/CMSIS/GD/GD32G5x3/Source/: system_gd32g5x3.c
    ../../../../Platform/GD32G5x3/Firmware/GD32G5x3_standard_peripheral/Source/: gd32g5x3_misc.c gd32g5x3_rcu.c gd32g5x3_usart.c gd32g5x3_gpio.c gd32g5x3_fmc.c gd32g5x3_syscfg.c
  group lib
    ../../../../Export/symbol/: ibl_symbol_mbedtls
