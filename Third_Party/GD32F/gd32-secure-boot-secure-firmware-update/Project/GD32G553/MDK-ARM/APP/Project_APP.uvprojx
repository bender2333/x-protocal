# Keil uVision project Project_APP.uvprojx, settings and files
target Target_GDM32 (6120000::V6.12::.\ARMCLANG)
  device: GD32G553QE GigaDevice
  pack: GigaDevice.GD32G5x3_DFP.0.2.2
  cpu: IRAM(0x20000000,0x18000) IRAM2(0x10000000,0x8000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: app +hex
  AfterMake: python ..\..\..\afterbuild.py project_deal -pn APP -op $L -on @L  -ide KEIL -ip $K
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PLATFORM_GD32G5X3, APP_TEST_SUIT, USE_STDPERIPH_DRIVER, GD32G5X3
  c misc: -fshort-wchar
  c include: ..\..\..\..\Utilities\Third_Party\mcuboot-main\boot\bootutil\include;..\..\..\..\Utilities\Third_Party\mcuboot-main\boot\gigadevice;..\..\..\..\..\gd32-secure-boot-secure-firmware-update;..\..\..\..\Utilities\Third_Party\mcuboot-main\boot\gigadevice\include;..\..\..\..\Platform\GD32G5x3\Firmware\CMSIS\GD\GD32G5x3\Include;..\..\..\..\Platform\GD32G5x3\Firmware\GD32G5x3_standard_peripheral\Include;..\..\..\..\Platform\GD32G5x3\Firmware\CMSIS;..\..\..\..\Platform\GD32G5x3;..\..\..\..\Platform\GD32G5x3\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: ..\..\..\..\Platform\GD32A513\armclang\app_gdm32.sct
  link misc: --predefine="-DPLATFORM_GD32G5X3"   --entry=Reset_Handler  --keep shellCommand*
  group application
    ../../../../Source/APP_Source/: main.c systick.c
    ../../../../Platform/GD32G5x3/Template/: gd32g5x3_it.c
  group CMSIS
    ../../../../Platform/GD32G5x3/Firmware/CMSIS/GD/GD32G5x3/Source/: system_gd32g5x3.c
  group Peripherals
    ../../../../Platform/GD32G5x3/Firmware/GD32G5x3_standard_peripheral/Source/: gd32g5x3_adc.c gd32g5x3_can.c gd32g5x3_cau.c gd32g5x3_cau_aes.c gd32g5x3_cau_des.c gd32g5x3_cau_tdes.c gd32g5x3_cmp.c gd32g5x3_cpdm.c gd32g5x3_crc.c gd32g5x3_dac.c gd32g5x3_dbg.c gd32g5x3_dma.c gd32g5x3_pmu.c gd32g5x3_cla.c gd32g5x3_exmc.c gd32g5x3_exti.c gd32g5x3_fac.c gd32g5x3_fft.c gd32g5x3_fmc.c gd32g5x3_fmc_ramfunc.c gd32g5x3_fwdgt.c gd32g5x3_gpio.c gd32g5x3_hpdf.c gd32g5x3_hrtimer.c gd32g5x3_i2c.c gd32g5x3_lptimer.c gd32g5x3_misc.c gd32g5x3_qspi.c gd32g5x3_rcu.c gd32g5x3_rtc.c gd32g5x3_spi.c gd32g5x3_syscfg.c gd32g5x3_timer.c gd32g5x3_tmu.c gd32g5x3_trigsel.c gd32g5x3_trng.c gd32g5x3_usart.c gd32g5x3_vref.c gd32g5x3_wwdgt.c
  group Startup
    ../../../../Platform/GD32G5x3/Firmware/CMSIS/GD/GD32G5x3/Source/ARM/: startup_gd32g5x3.s
  group Utilities
    ../../../../Platform/GD32G5x3/Utilities/: gd32g553q_eval.c
  group lib
    ../../../../Export/symbol/: mbl_symbol ibl_symbol_mbedtls
  group Letter_shell
    ../../../../Utilities/Third_Party/letter-shell-shell2.x/: shell.c shell_ext.c
    ../../../../Source/APP_Source/shell_drv_uart/: drv_uart.c
  group Common
    ../../../../Source/APP_Source/Common/: task.c reboot.c ymodem_update.c
  group Test
    ../../../../Source/Test_Source/APP_Test/: app_test_suit.c
software components: CMSIS:CORE 5.2.0
